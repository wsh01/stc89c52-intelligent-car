# Keil uVision project Themp.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Themp +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: main.c delay.c delay.h run.c run.h chaoshengbo.c chaoshengbo.h comm.c comm.h bizhang.c bizhang.h bluetooth.c bluetooth.h iic.c iic.h oled.c oled.h oled_main.c oled_main.h
